# Keil uVision project LT7689.uvprojx, settings and files
target LT7689 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: LT7689 +hex
  AfterMake: fromelf.exe --bin -o ./OBJ/bin/MCU_Code.bin  ./OBJ/obj_debug_efm/@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING,__CC_ARM
  c misc: --gnu
  c include: .\ccore\common;.\ccore;.\Function;.\Function_drv;.\Levetoplib;.\MCU_drv\drv\inc;.\MCU_drv\drv\src;.\MCU_drv\lib;.\QRCODE;.\User;.\MCU_drv\drv\src\usb
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x75000
  memory RVCT9: RAM 0x20000000 size 0x38000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  group User
    ./User/: main.c module_select.h bsp_user.c bsp.c
  group ccore
    ./ccore/common/: common.c sys.c
    ./ccore/: system_ARMCM4.c startup_ARMCM4.s
  group MCU_drv
    ./MCU_drv/drv/src/: adc_dma.c adc_drv.c alg_drv.c cache_drv.c ccm_drv.c cpm_drv.c crc_drv.c dac_drv.c dmac_drv.c edma_drv.c eflash_drv.c i2c_drv.c eport_drv.c ioctrl_drv.c pci_drv.c pit32_drv.c pwm_drv.c reset_drv.c rtc_drv.c spi_drv.c ssi_drv.c systick_drv.c tc_drv.c trng_drv.c uart_drv.c wdt_drv.c
    ./MCU_drv/lib/: arm_cortexM4_math.lib libAlgorithm.lib libBT_ATT8761.lib libClkSwitch.lib libEFlash.lib libGetSN.lib libLockJtag.lib libRegOpt.lib libTSI.lib
    ./MCU_drv/drv/src/usb/: usb_hid_control.c usb_hid_isr.c usb_drv.c usbdev_control.c usbdev_isr.c usb_ms_control.c usb_ms_config.c usb_cdc_control.c usb_cdc_config.c usb_ccid_contril.c usb_ccid_config.c
  group Function_drv
    ./Function_drv/: dac.c delay.c dma.c if_port.c iic.c pit.c rtc.c tp_drv.c uart.c
  group Function
    ./Function/: ctp.c data.c flash.c LT768.c LT768_Lib.c rtp.c gbk.c w25n01.c w25qxx.c sincostable.c
  group Levetoplib
    ./Levetoplib/: levetop.lib
  group QRCODE
    ./QRCODE/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
